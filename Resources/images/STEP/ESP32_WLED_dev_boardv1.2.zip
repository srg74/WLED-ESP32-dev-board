# Autodesk Inventor part: SOLID
Saved by Autodesk Inventor 2021.3 (Build 253353000, 353)
## iProperties
Created: 2022-06
Part Number: SOLID
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: SOLID
Author: Administrator
## Design history (mm, degrees)
feature "Body1"
body "Solid1"
